# IAR project Project.ewp, settings and files
configuration Debug_STSELIB_project_template_NUCLEO-L452RE (ARM, debug)
  General.OGChipSelectEditMenu: STM32L452RE ST STM32L452RE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: __VFP_FP__; STM32L452xx; DEBUG
  ICCARM.CCIncludePath2: ..\..\..\..\..\; ..\..\..\..\..\Middleware\STSELib; ..\..\..\..\..\Middleware\STM32_Cryptographic\include; ..\..\..\..\..\Middleware\STM32_Cryptographic\legacy_v3\include; ..\..\..\..\..\Middleware\STM32_Cryptographic\legacy_v3\src; ..\..\..\..\..\Platforms\NUCLEO-L452RE; ..\..\..\..\..\Platforms\NUCLEO-L452RE\Core\CMSIS\Include; ..\..\..\..\..\Platforms\NUCLEO-L452RE\Core\CMSIS\Device\ST\STM32L4xx\Include; ..\..\..\..\..\Platforms\NUCLEO-L452RE\Drivers; ..\..\..\..\..\Platforms\NUCLEO-L452RE\STSAFE-A1xx
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.bin
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: ..\..\..\..\..\Platforms\NUCLEO-L452RE\Core\CMSIS\Device\ST\STM32L4xx\Source\iar\linker\stm32l452xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release_STSELIB_project_template_NUCLEO-L452RE (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: __VFP_FP__; STM32L452xx
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  group App
    ../../: main.c
    ../../../../../Platforms/NUCLEO-L452RE/Core/CMSIS/Device/ST/STM32L4xx/Source/iar/: startup_stm32l452xx.s
  group App/Apps utils
    ../../../../Apps_utils/: Apps_utils.c
  group Middleware/STM32CryptoLib
    ../../../../../Middleware/STM32_Cryptographic/interface/: cmox_low_level.c
    ../../../../../Middleware/STM32_Cryptographic/lib/: libSTM32Cryptographic_CM4.a
  group Middleware/STSELib/api
    ../../../../../Middleware/STSELib/api/: stse_aes.c stse_asymmetric_keys_management.c stse_data_storage.c stse_device_authentication.c stse_device_management.c stse_ecc.c stse_hash.c stse_mac.c stse_random.c stse_symmetric_keys_management.c
  group Middleware/STSELib/Certificate
    ../../../../../Middleware/STSELib/certificate/: stse_certificate.c stse_certificate_crypto.c stse_certificate_prints.c stse_certificate_subparsing.c
  group Middleware/STSELib/Core
    ../../../../../Middleware/STSELib/core/: stse_device.c stse_frame.c stse_platform.c stse_session.c
  group Middleware/STSELib/Services
    ../../../../../Middleware/STSELib/services/stsafea/: stsafea_aes.c stsafea_asymmetric_key_slots.c stsafea_commands.c stsafea_data_partition.c stsafea_ecc.c stsafea_echo.c stsafea_hash.c stsafea_host_key_slot.c stsafea_low_power.c stsafea_mac.c stsafea_password.c stsafea_patch.c stsafea_put_query.c stsafea_random.c stsafea_reset.c stsafea_sessions.c stsafea_symmetric_key_slots.c stsafea_timings.c stsafea_wrap_unwrap.c
  group Platform/Core
    ../../../../../Platforms/NUCLEO-L452RE/Core/CMSIS/Device/ST/STM32L4xx/Source/: system_stm32l4xx.c
  group Platform/Drivers
    ../../../../../Platforms/NUCLEO-L452RE/Drivers/crc16/: crc16.c
    ../../../../../Platforms/NUCLEO-L452RE/Drivers/delay_ms/: delay_ms.c
    ../../../../../Platforms/NUCLEO-L452RE/Drivers/delay_us/: delay_us.c
    ../../../../../Platforms/NUCLEO-L452RE/Drivers/i2c/: I2C.c
    ../../../../../Platforms/NUCLEO-L452RE/Drivers/rng/: rng.c
    ../../../../../Platforms/NUCLEO-L452RE/Drivers/uart/: uart.c
  group Platform/STSAFE-A1xx
    ../../../../../Platforms/NUCLEO-L452RE/STSAFE-A1xx/: stse_platform_crypto.c stse_platform_i2c_dynamic.c stse_platform_i2c_static.c stse_platform_services.c
